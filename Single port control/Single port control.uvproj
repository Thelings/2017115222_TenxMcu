# Keil uVision project Single port control.uvproj, settings and files
target Target 1 (MCS-51)
  device: TM52F5278B tenx
  cpu: IRAM(0-0xFF) CLOCK(8000000) XRAM(0xFF00-0xFFFF)
  output: Single port control
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP_TENX52.A51 display.c display.h includeAll.h init.c init.h keys.c keys.h main.c main.h REGtenxTM52F5278B.h typeAlias.h
