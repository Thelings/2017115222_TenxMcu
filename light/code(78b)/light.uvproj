# Keil uVision project light.uvproj, settings and files
target Target 1 (MCS-51)
  device: TM52F5278B tenx
  cpu: IRAM(0-0xFF) CLOCK(8000000) XRAM(0xFF00-0xFFFF)
  output: light
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./code(78b)/: display.c display.h includeAll.h init.c init.h isr.c isr.h keys.c keys.h main.c main.h REGtenxTM52F5278B.h STARTUP_TENX52.A51 typeAlias.h
