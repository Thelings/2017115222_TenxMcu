# Keil uVision project major_paper.uvproj, settings and files
target Target 1 (MCS-51)
  device: TM52F5268B tenx
  cpu: IRAM(0-0xFF) CLOCK(8000000)
  output: major_paper +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP_TENX52.A51 display.c display.h includeAll.h main.c main.h typeAlias.h init.c init.h
